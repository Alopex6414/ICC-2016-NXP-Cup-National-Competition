# IAR project Kinetis_K60.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\dma; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\spi; ..\..\src\drivers\sdhc; ..\..\src\app; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\build
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Kinetis_K60.bin
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: ..\config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\projects\fire_gpio_demo; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\build
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  group app/C
    ../../src/app/: bootloader.c ctrl.c fun.c fuzzy.c getinfor.c I2C.c init.c isr.c keyboard.c main.c Oled.c TFT.c
  group app/H
    ../../src/app/: bootloader.h ctrl.h dac.h declare.h font.h fun.h fuzzy.h getinfor.h I2C.h init.h isr.h keyboard.h Oled.h TFT.h
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/adc/: adc.c
    ../../src/drivers/dac/: dac.c
    ../../src/drivers/delay/: delay.c
    ../../src/LIB/FatFs/: diskio.c
    ../../src/drivers/dma/: dma.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/Flash/: flash.c
    ../../src/drivers/flash_cfg/: flash_cfg.c FlashCommandSequence.c FlashEraseSector.c FlashProgramPhrase.c FlashVerifySection.c SSD_FTFx.h
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/rtc/: rtc.c
    ../../src/drivers/sdhc/: sdhc.c
    ../../src/drivers/spi/: spi.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/w25x16/: w25x16.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/common/: common.h
    ../../src/platforms/: k60_fire.h
  group LIB/CMSIS
    ../../src/LIB/CMSIS/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h iar_cortexM4l_math.a
  group LIB/FATFS
    ../../src/LIB/FatFs/: ff.c
