<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\build\Kinetis_K60\Kinetis_K60.ewp</path>
  </project>
  <batchBuild/>
</workspace>


